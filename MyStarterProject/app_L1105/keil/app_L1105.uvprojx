# Keil uVision project app_L1105.uvprojx, settings and files
target app_L1105 (6180000::V6.18::ARMCLANG)
  device: MSPM0L1105 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: app_L1105 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1105__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../source;C:\ti\mspm0_sdk_2_05_01_00\source;C:\ti\mspm0_sdk_2_05_01_00\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1105.sct
  group Source
    ../: main.c ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l110x_uvision.s
  group Driverlib
    C:/ti/mspm0_sdk_2_05_01_00/source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
